<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\10.SPI and 74hc595.ewp</path>
  </project>
  <batchBuild />
</workspace>
