<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Master and Slave Bluetooth.ewp</path>
  </project>
  <batchBuild />
</workspace>
