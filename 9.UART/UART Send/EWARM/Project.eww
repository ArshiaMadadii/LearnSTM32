<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\9.UART.ewp</path>
  </project>
  <batchBuild />
</workspace>
